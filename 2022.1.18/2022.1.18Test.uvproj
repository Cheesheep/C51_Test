# Keil uVision project 2022.1.18Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 2022.1.18Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c include.h
  group TestSave
    ./: LEDtest.h LEDtest.c Key_Clock_LCDTest.h Key_Clock_LCDTest.c LCD1602.h LCD1602.c PWM_BreathLED.h PWM_BreathLED.c
  group FunLib
    ./: basicFun.h basicFun.c
